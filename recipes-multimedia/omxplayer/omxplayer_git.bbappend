DEPENDS = "libpcre ffmpeg virtual/egl boost freetype dbus openssl samba libssh"
