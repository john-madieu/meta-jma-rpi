CFLAGS += "-liconv"
