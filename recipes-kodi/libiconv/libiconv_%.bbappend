FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = " file://0001-fixed-stdio.in.h-bug.patch"

PROVIDES = ""
